Commit message: URDF fix warning and increase spacing of wall to 40cm

File: data/turtlebot3.urdf (robot description, URDF)
Before this commit: robot turtlebot3_burger, 7 links, 6 joints
Links:
- link base_footprint: mass None -> 1.000
- link imu_link: mass None -> 0.000
